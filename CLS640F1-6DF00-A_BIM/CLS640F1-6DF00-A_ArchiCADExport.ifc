Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-11-07T13:58:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 07 13:58:54 2022 * Host: CHATPONG-DEE * Database: C:\Users\CHATPONG\AppData\Local\Temp\{3F7F3AC3-A813-4F3B-8E86-2986CDCC4D00}\ifc * Database version: 5507 * Database creation date: Mon Nov 07 13:58:46 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 07 13:58:46 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 07 13:58:46 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowTerminal: CERAFINE Vessel Basin w/ Deck - Squoval, CLS640F1-6DF00-A_REVIT:CERAFINE Vessel Basin w/ Deck - Squoval:353089
In: Level 1
Material: White
Pset_DistributionFlowElementCommon - Reference: CERAFINE Vessel Basin w/ Deck - Squoval
